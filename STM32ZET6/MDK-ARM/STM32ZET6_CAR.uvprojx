# Keil uVision project STM32ZET6_CAR.uvprojx, settings and files
target STM32ZET6_CAR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32ZET6_CAR +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Users/APP;../Users/Encoder;../Users/Motor;../Users/OLED;../Users/PWM;../Users/USART;../Users/LED;../Users/Grayscale;../Users/Protocol;../Users/CJSON;../Users/LCD;../Users/KEY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Hardware
    ../Users/APP/: app.c
    ../Users/Encoder/: encoder.c
    ../Users/LED/: led.c
    ../Users/Motor/: motor.c
    ../Users/OLED/: oled.c
    ../Users/PWM/: pwm.c
    ../Users/Grayscale/: Grayscale.c
    ../Users/Protocol/: protocol.c
    ../Users/USART/: serial_it_config.c debug.c usart_2.c usart_3.c usart_4.c
    ../Users/CJSON/: cJSON.c
    ../Users/LCD/: LCD.c LCD.h
    ../Users/KEY/: key.c key.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
